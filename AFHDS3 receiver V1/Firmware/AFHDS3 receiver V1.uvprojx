# Keil uVision project AFHDS3 receiver V1.uvprojx, settings and files
target FGr4B debug (6140001::V6.14.1::ARMCLANG)
  device: STM32G070CBTx STMicroelectronics
  pack: Keil.STM32G0xx_DFP.1.3.0
  cpu: IRAM(0x20000000,0x00009000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: FGr4B
  c flags: Optim=2 oTime=1 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: PN_FGR4B AFHDS3_VERSION=1 ROLE_RX PHY_SX1280 NPT_NB_CHANNELS=4 SES_NPT_NB_PORTS=4 DEBUG
  c include: .;..\include;..\..;..\..\Include;..\..\AFHDS3 receiver V1
  memory RVCT4: ROM 0x8006000 size 0xf80
  memory RVCT5: ROM 0x8007000 size 0x19000
  memory RVCT9: RAM 0x20000080 size 0x8f80
  link misc: --any_placement=worst_fit
  group Source Group 1
    ./: startup_stm32f051x8.s startup_stm32g070xx.s startup_stm32g071xx.s ADC.c Bmp280.c EEPROM.c Encryption.c Flash.c FC.c Gyro.c GyroFC.c PID FC.c GyroGMr.c IMU.c I2C.c Main.c NPT timer.c PWM adapter.c System.c USART New Port.c Resource.txt
    ../: SPI SX1280.c LNK timer.c LED.c System receiver.c Encryption library M0 release.lib
    ../../Lib/: AFHDS3 CRC library M0+ release.lib AFHDS3 PWM frequencies packing library M0+ release.lib AFHDS3 RC channels packing library M0+ release.lib AFHDS3 queue low priority IRQ library 8Q4Q M0+ release.lib AFHDS3 queue medium priority IRQ library 8Q32Q M0+ release.lib AFHDS3 simple random number library M0+ release.lib AFHDS3 SX1280 receiver V1 M0+ release.lib i-Bus 1 device library M0+ release.lib i-Bus 2 device library M0+ release.lib New Port 1 channel 1 port M0+ release.lib New Port 4 channels 0 port M0 release.lib New Port 4 channels 4 ports M0+ release.lib New Port 6 channels 4 ports M0+ release.lib New Port 8 channels 4 ports M0+ release.lib New Port 12 channels 4 ports M0+ release.lib
target FGr4B release (6140001::V6.14.1::ARMCLANG)
  device: STM32G070CBTx STMicroelectronics
  pack: Keil.STM32G0xx_DFP.1.3.0
  cpu: as above
  output: FGr4B +hex
  AfterMake: cmd /c "Post FGr4B release.bat"
  c flags: Optim=5 oTime=1 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 v6Lto=1 wLevel=2
  c define: PN_FGR4B AFHDS3_VERSION=1 ROLE_RX PHY_SX1280 NPT_NB_CHANNELS=4 SES_NPT_NB_PORTS=4
  c include: .;..\include;..\..;..\..\Include;..\..\AFHDS3 receiver V1
  memory RVCT4: ROM 0x8006000 size 0xf80
  memory RVCT5: ROM 0x8007000 size 0x19000
  memory RVCT9: RAM 0x20000080 size 0x8f80
  link misc: --any_placement=worst_fit
target FTr8B debug (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32G070CBTx STMicroelectronics
  pack: Keil.STM32G0xx_DFP.1.3.0
  cpu: as above
  output: FTr8B
  c flags: Optim=1 oTime=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: PN_FTR8B AFHDS3_VERSION=1 ROLE_RX PHY_SX1280 NPT_NB_CHANNELS=8 SES_NPT_NB_PORTS=4 DEBUG
  c include: .;..\include;..\..;..\..\Include;..\..\AFHDS3 receiver V1
  memory RVCT4: ROM 0x8006000 size 0xf80
  memory RVCT5: ROM 0x8007000 size 0x19000
  memory RVCT9: RAM 0x20000080 size 0x8f80
  link misc: --any_placement=worst_fit
target FTr8B release (6090000::V6.9::.\ARMCLANG)
  device: STM32G070CBTx STMicroelectronics
  pack: Keil.STM32G0xx_DFP.1.3.0
  cpu: as above
  output: FTr8B +hex
  AfterMake: cmd /c "Post FTr8B release.bat"
  c flags: as above
  c define: PN_FTR8B AFHDS3_VERSION=1 ROLE_RX NPT_NB_CHANNELS=8 SES_NPT_NB_PORTS=4 PHY_SX1280
  c include: .;..\include;..\..;..\..\Include;..\..\AFHDS3 receiver V1
  memory RVCT4: ROM 0x8006000 size 0xf80
  memory RVCT5: ROM 0x8007000 size 0x19000
  memory RVCT9: RAM 0x20000080 size 0x8f80
  link misc: --any_placement=worst_fit
target FGr8B debug (6140001::V6.14.1::ARMCLANG)
  device: STM32G070CBTx STMicroelectronics
  pack: Keil.STM32G0xx_DFP.1.3.0
  cpu: as above
  output: FGr8B
  c flags: Optim=2 oTime=1 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: PN_FGR8B AFHDS3_VERSION=1 ROLE_RX PHY_SX1280 NPT_NB_CHANNELS=8 SES_NPT_NB_PORTS=4 DEBUG
  c include: .;..\include;..\..;..\..\Include;..\..\AFHDS3 receiver V1
  memory RVCT4: ROM 0x8006000 size 0xf80
  memory RVCT5: ROM 0x8007000 size 0x19000
  memory RVCT9: RAM 0x20000080 size 0x8f80
  link misc: --any_placement=worst_fit
target FGr8B release (6140001::V6.14.1::ARMCLANG)
  device: STM32G070CBTx STMicroelectronics
  pack: Keil.STM32G0xx_DFP.1.3.0
  cpu: as above
  output: FGr8B +hex
  AfterMake: cmd /c "Post FGr8B release.bat"
  c flags: as above
  c define: PN_FGR8B AFHDS3_VERSION=1 ROLE_RX NPT_NB_CHANNELS=8 SES_NPT_NB_PORTS=4 PHY_SX1280
  c include: .;..\..;..\include;..\..\Include;..\..\AFHDS3 receiver V1
  memory RVCT4: ROM 0x8006000 size 0xf80
  memory RVCT5: ROM 0x8007000 size 0x19000
  memory RVCT9: RAM 0x20000080 size 0x8f80
  link misc: --any_placement=worst_fit
target FTr12B debug (6140001::V6.14.1::ARMCLANG)
  device: STM32G070CBTx STMicroelectronics
  pack: Keil.STM32G0xx_DFP.1.3.0
  cpu: as above
  output: FTr12B
  c flags: Optim=2 oTime=1 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: PN_FTR12B AFHDS3_VERSION=1 ROLE_RX PHY_SX1280 NPT_NB_CHANNELS=12 SES_NPT_NB_PORTS=4 DEBUG
  c misc: -ffreestanding
  c include: .;..\include;..\..;..\..\Include;..\..\AFHDS3 receiver V1
  memory RVCT4: ROM 0x8006000 size 0xf80
  memory RVCT5: ROM 0x8007000 size 0x19000
  memory RVCT9: RAM 0x20000080 size 0x8f80
  link misc: --any_placement=worst_fit
target FTr12B release (6140001::V6.14.1::ARMCLANG)
  device: STM32G070CBTx STMicroelectronics
  pack: Keil.STM32G0xx_DFP.1.3.0
  cpu: as above
  output: FTr12B +hex
  AfterMake: cmd /c "Post FTr12B release.bat"
  c flags: as above
  c define: PN_FTR12B AFHDS3_VERSION=1 ROLE_RX NPT_NB_CHANNELS=12 SES_NPT_NB_PORTS=4 PHY_SX1280
  c include: .;..\include;..\..;..\..\Include;..\..\AFHDS3 receiver V1
  memory RVCT4: ROM 0x8006000 size 0xf80
  memory RVCT5: ROM 0x8007000 size 0x19000
  memory RVCT9: RAM 0x20000080 size 0x8f80
  link misc: --any_placement=worst_fit
target FGr12B debug (6140001::V6.14.1::ARMCLANG)
  device: STM32G070CBTx STMicroelectronics
  pack: Keil.STM32G0xx_DFP.1.3.0
  cpu: as above
  output: FGr12B
  c flags: Optim=2 oTime=1 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: PN_FGR12B AFHDS3_VERSION=1 ROLE_RX PHY_SX1280 NPT_NB_CHANNELS=12 SES_NPT_NB_PORTS=4 DEBUG
  c include: .;..\include;..\..;..\..\Include;..\..\AFHDS3 receiver V1
  memory RVCT4: ROM 0x8006000 size 0xf80
  memory RVCT5: ROM 0x8007000 size 0x19000
  memory RVCT9: RAM 0x20000080 size 0x8f80
  link misc: --any_placement=worst_fit
target FGr12B release (6140001::V6.14.1::ARMCLANG)
  device: STM32G070CBTx STMicroelectronics
  pack: Keil.STM32G0xx_DFP.1.3.0
  cpu: as above
  output: FGr12B +hex
  AfterMake: cmd /c "Post FGr12B release.bat"
  c flags: as above
  c define: PN_FGR12B AFHDS3_VERSION=1 ROLE_RX NPT_NB_CHANNELS=12 SES_NPT_NB_PORTS=4 PHY_SX1280
  c include: .;..\include;..\..;..\..\Include;..\..\AFHDS3 receiver V1
  memory RVCT4: ROM 0x8006000 size 0xf80
  memory RVCT5: ROM 0x8007000 size 0x19000
  memory RVCT9: RAM 0x20000080 size 0x8f80
  link misc: --any_placement=worst_fit
target INR4-GYB debug (6090000::V6.9::.\ARMCLANG)
  device: STM32G070CBTx STMicroelectronics
  pack: Keil.STM32G0xx_DFP.1.3.0
  cpu: as above
  output: INR4-GYB
  c flags: Optim=2 oTime=1 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: PN_INR4_GYB AFHDS3_VERSION=1 ROLE_RX PHY_SX1280 NPT_NB_CHANNELS=4 SES_NPT_NB_PORTS=4 DEBUG
  c include: .;..\include;..\..;..\..\Include;..\..\AFHDS3 receiver V1
  memory RVCT4: ROM 0x8006000 size 0xf80
  memory RVCT5: ROM 0x8007000 size 0x19000
  memory RVCT9: RAM 0x20000080 size 0x8f80
  link misc: --any_placement=worst_fit
target INR4-GYB release (6090000::V6.9::.\ARMCLANG)
  device: STM32G070CBTx STMicroelectronics
  pack: Keil.STM32G0xx_DFP.1.3.0
  cpu: as above
  output: INR4-GYB +hex
  AfterMake: cmd /c "Post INR4-GYB release.bat"
  c flags: Optim=2 oTime=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 v6Lto=1 wLevel=3
  c define: PN_INR4_GYB AFHDS3_VERSION=1 ROLE_RX PHY_SX1280 NPT_NB_CHANNELS=4 SES_NPT_NB_PORTS=4
  c include: .;..\include;..\..;..\..\Include;..\..\AFHDS3 receiver V1
  memory RVCT4: ROM 0x8006000 size 0xf80
  memory RVCT5: ROM 0x8007000 size 0x19000
  memory RVCT9: RAM 0x20000080 size 0x8f80
  link misc: --any_placement=worst_fit
target INr6-HS debug (6140001::V6.14.1::ARMCLANG)
  device: STM32G071KBUx STMicroelectronics
  pack: Keil.STM32G0xx_DFP.1.3.0
  cpu: as above
  output: INr6-HS
  c flags: Optim=2 oTime=1 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: PN_INR6_HS AFHDS3_VERSION=1 ROLE_RX PHY_SX1280 NPT_NB_CHANNELS=6 SES_NPT_NB_PORTS=4 DEBUG
  c include: .;..\include;..\..;..\..\Include;..\..\AFHDS3 receiver V1
  memory RVCT4: ROM 0x8006000 size 0xf80
  memory RVCT5: ROM 0x8007000 size 0x19000
  memory RVCT9: RAM 0x20000080 size 0x8f80
  link misc: --any_placement=worst_fit
target INr6-HS release (6140001::V6.14.1::ARMCLANG)
  device: STM32G071KBUx STMicroelectronics
  pack: Keil.STM32G0xx_DFP.1.3.0
  cpu: as above
  output: INr6-HS +hex
  AfterMake: cmd /c "Post INr6-HS release.bat"
  c flags: as above
  c define: PN_INR6_HS AFHDS3_VERSION=1 ROLE_RX PHY_SX1280 NPT_NB_CHANNELS=6 SES_NPT_NB_PORTS=4
  c include: .;..\include;..\..;..\..\Include;..\..\AFHDS3 receiver V1
  memory RVCT4: ROM 0x8006000 size 0xf80
  memory RVCT5: ROM 0x8007000 size 0x19000
  memory RVCT9: RAM 0x20000080 size 0x8f80
  link misc: --any_placement=worst_fit
target GMr debug (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F051K8Ux STMicroelectronics
  pack: Keil.STM32F0xx_DFP.2.0.0
  cpu: IRAM(0x20000000,0x00002000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: GMr
  c flags: Optim=2 oTime=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: PN_GMR AFHDS3_VERSION=1 ROLE_RX PHY_SX1280 NPT_NB_CHANNELS=4 SES_NPT_NB_PORTS=0 DEBUG
  c include: .;..\include;..\..;..\..\Include;..\..\AFHDS3 receiver V1
  memory RVCT4: ROM 0x8003000 size 0xf80
  memory RVCT5: ROM 0x8004000 size 0xc000
  memory RVCT9: RAM 0x20000080 size 0x1f80
  link misc: --any_placement=worst_fit
target GMr release (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F051K8Ux STMicroelectronics
  pack: Keil.STM32F0xx_DFP.2.0.0
  cpu: as above
  output: GMr +hex
  AfterMake: cmd /c "Post GMr release.bat"
  c flags: Optim=4 oTime=1 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 v6Lto=1 wLevel=2
  c define: PN_GMR AFHDS3_VERSION=1 ROLE_RX PHY_SX1280 NPT_NB_CHANNELS=4 SES_NPT_NB_PORTS=0
  c include: .;..\include;..\..;..\..\Include;..\..\AFHDS3 receiver V1
  memory RVCT4: ROM 0x8003000 size 0xf80
  memory RVCT5: ROM 0x8004000 size 0xc000
  memory RVCT9: RAM 0x20000080 size 0x1f80
  link misc: --any_placement=worst_fit
target TMr debug (6140001::V6.14.1::ARMCLANG)
  device: STM32G071KBUx STMicroelectronics
  pack: Keil.STM32G0xx_DFP.1.3.0
  cpu: as above
  output: TMr
  c flags: Optim=2 oTime=1 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: PN_TMR AFHDS3_VERSION=1 ROLE_RX PHY_SX1280 NPT_NB_CHANNELS=1 SES_NPT_NB_PORTS=1 DEBUG
  c include: .;..\include;..\..;..\..\Include;..\..\AFHDS3 receiver V1
  memory RVCT4: ROM 0x8006000 size 0xf80
  memory RVCT5: ROM 0x8007000 size 0x19000
  memory RVCT9: RAM 0x20000080 size 0x8f80
  link misc: --any_placement=worst_fit
target TMr release (6140001::V6.14.1::ARMCLANG)
  device: STM32G071KBUx STMicroelectronics
  pack: Keil.STM32G0xx_DFP.1.3.0
  cpu: as above
  output: TMr +hex
  AfterMake: cmd /c "Post TMr release.bat"
  c flags: Optim=6 oTime=1 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 v6Lto=1 wLevel=2
  c define: PN_TMR AFHDS3_VERSION=1 ROLE_RX PHY_SX1280 NPT_NB_CHANNELS=1 SES_NPT_NB_PORTS=1
  c include: .;..\include;..\..;..\..\Include;..\..\AFHDS3 receiver V1
  memory RVCT4: ROM 0x8006000 size 0xf80
  memory RVCT5: ROM 0x8007000 size 0x19000
  memory RVCT9: RAM 0x20000080 size 0x8f80
  link misc: --any_placement=worst_fit
target FBr12 debug (6140001::V6.14.1::ARMCLANG)
  device: STM32G070CBTx STMicroelectronics
  pack: Keil.STM32G0xx_DFP.1.3.0
  cpu: as above
  output: FBr12
  c flags: Optim=2 oTime=1 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: PN_FBR12 AFHDS3_VERSION=1 ROLE_RX PHY_SX1280 NPT_NB_CHANNELS=12 SES_NPT_NB_PORTS=4 DEBUG
  c misc: -ffreestanding
  c include: .;..\include;..\..;..\..\Include;..\..\AFHDS3 receiver V1
  memory RVCT4: ROM 0x8006000 size 0xf80
  memory RVCT5: ROM 0x8007000 size 0x19000
  memory RVCT9: RAM 0x20000080 size 0x8f80
  link misc: --any_placement=worst_fit
target FBr12  release (6140001::V6.14.1::ARMCLANG)
  device: STM32G070CBTx STMicroelectronics
  pack: Keil.STM32G0xx_DFP.1.3.0
  cpu: as above
  output: FBr12 +hex
  AfterMake: cmd /c "Post FBr12 release.bat"
  c flags: as above
  c define: PN_FBR12  AFHDS3_VERSION=1 ROLE_RX NPT_NB_CHANNELS=12 SES_NPT_NB_PORTS=4 PHY_SX1280
  c include: .;..\include;..\..;..\..\Include;..\..\AFHDS3 receiver V1
  memory RVCT4: ROM 0x8006000 size 0xf80
  memory RVCT5: ROM 0x8007000 size 0x19000
  memory RVCT9: RAM 0x20000080 size 0x8f80
  link misc: --any_placement=worst_fit
target INr6-FC debug (6140001::V6.14.1::ARMCLANG)
  device: STM32G071KBUx STMicroelectronics
  pack: Keil.STM32G0xx_DFP.1.3.0
  cpu: as above
  output: INr6-FC
  c flags: Optim=2 oTime=1 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: PN_INR6_FC AFHDS3_VERSION=1 ROLE_RX PHY_SX1280 NPT_NB_CHANNELS=6 SES_NPT_NB_PORTS=4 DEBUG
  c include: .;..\include;..\..;..\..\Include;..\..\AFHDS3 receiver V1
  memory RVCT4: ROM 0x8006000 size 0xf80
  memory RVCT5: ROM 0x8007000 size 0x19000
  memory RVCT9: RAM 0x20000080 size 0x8f80
  link misc: --any_placement=worst_fit
target INr6-FC release (6140001::V6.14.1::ARMCLANG)
  device: STM32G071KBUx STMicroelectronics
  pack: Keil.STM32G0xx_DFP.1.3.0
  cpu: as above
  output: INr6-FC +hex
  AfterMake: cmd /c "Post INr6-FC release.bat"
  c flags: Optim=1 oTime=1 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 v6Lto=1 wLevel=2
  c define: PN_INR6_FC AFHDS3_VERSION=1 ROLE_RX PHY_SX1280 NPT_NB_CHANNELS=6 SES_NPT_NB_PORTS=4
  c include: .;..\include;..\..;..\..\Include;..\..\AFHDS3 receiver V1
  library: MicroLIB
  memory RVCT4: ROM 0x8006000 size 0xf80
  memory RVCT5: ROM 0x8007000 size 0x19000
  memory RVCT9: RAM 0x20000080 size 0x8f80
  link misc: --any_placement=worst_fit
target Tr8B debug (6140001::V6.14.1::ARMCLANG)
  device: STM32G071KBUx STMicroelectronics
  pack: Keil.STM32G0xx_DFP.1.3.0
  cpu: as above
  output: Tr8B
  c flags: Optim=2 oTime=1 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: PN_TR8B AFHDS3_VERSION=1 ROLE_RX PHY_SX1280 NPT_NB_CHANNELS=8 SES_NPT_NB_PORTS=4 DEBUG
  c include: .;..\include;..\..;..\..\Include;..\..\AFHDS3 receiver V1
  memory RVCT4: ROM 0x8006000 size 0xf80
  memory RVCT5: ROM 0x8007000 size 0x19000
  memory RVCT9: RAM 0x20000080 size 0x8f80
  link misc: --any_placement=worst_fit
target Tr8B release (6140001::V6.14.1::ARMCLANG)
  device: STM32G071KBUx STMicroelectronics
  pack: Keil.STM32G0xx_DFP.1.3.0
  cpu: as above
  output: Tr8B +hex
  AfterMake: cmd /c "Post Tr8B release.bat"
  c flags: as above
  c define: PN_TR8B AFHDS3_VERSION=1 ROLE_RX NPT_NB_CHANNELS=8 SES_NPT_NB_PORTS=2 PHY_SX1280
  c include: .;..\include;..\..;..\..\Include;..\..\AFHDS3 receiver V1
  memory RVCT4: ROM 0x8006000 size 0xf80
  memory RVCT5: ROM 0x8007000 size 0x19000
  memory RVCT9: RAM 0x20000080 size 0x8f80
  link misc: --any_placement=worst_fit
target FBr8 debug (6090000::V6.9::.\ARMCLANG)
  device: STM32G070CBTx STMicroelectronics
  pack: Keil.STM32G0xx_DFP.1.3.0
  cpu: as above
  output: FBr8
  c flags: Optim=2 oTime=1 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: PN_FBR8 AFHDS3_VERSION=1 ROLE_RX PHY_SX1280 NPT_NB_CHANNELS=8 SES_NPT_NB_PORTS=4 DEBUG
  c misc: -ffreestanding
  c include: .;..\include;..\..;..\..\Include;..\..\AFHDS3 receiver V1
  memory RVCT4: ROM 0x8006000 size 0xf80
  memory RVCT5: ROM 0x8007000 size 0x19000
  memory RVCT9: RAM 0x20000080 size 0x8f80
  link misc: --any_placement=worst_fit
target FBr8  release (6140001::V6.14.1::ARMCLANG)
  device: STM32G070CBTx STMicroelectronics
  pack: Keil.STM32G0xx_DFP.1.3.0
  cpu: as above
  output: FBr8 +hex
  AfterMake: cmd /c "Post FBr8 release.bat"
  c flags: as above
  c define: PN_FBR8  AFHDS3_VERSION=1 ROLE_RX NPT_NB_CHANNELS=8 SES_NPT_NB_PORTS=4 PHY_SX1280
  c include: .;..\include;..\..;..\..\Include;..\..\AFHDS3 receiver V1
  memory RVCT4: ROM 0x8006000 size 0xf80
  memory RVCT5: ROM 0x8007000 size 0x19000
  memory RVCT9: RAM 0x20000080 size 0x8f80
  link misc: --any_placement=worst_fit
target FBr4 debug (6140001::V6.14.1::ARMCLANG)
  device: STM32G070CBTx STMicroelectronics
  pack: Keil.STM32G0xx_DFP.1.3.0
  cpu: as above
  output: FBr4
  c flags: Optim=2 oTime=1 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: PN_FBR4 AFHDS3_VERSION=1 ROLE_RX PHY_SX1280 NPT_NB_CHANNELS=4 SES_NPT_NB_PORTS=4 DEBUG
  c misc: -ffreestanding
  c include: .;..\include;..\..;..\..\Include;..\..\AFHDS3 receiver V1
  memory RVCT4: ROM 0x8006000 size 0xf80
  memory RVCT5: ROM 0x8007000 size 0x19000
  memory RVCT9: RAM 0x20000080 size 0x8f80
  link misc: --any_placement=worst_fit
target FBr4  release (6140001::V6.14.1::ARMCLANG)
  device: STM32G070CBTx STMicroelectronics
  pack: Keil.STM32G0xx_DFP.1.3.0
  cpu: as above
  output: FBr4 +hex
  AfterMake: cmd /c "Post FBr4 release.bat"
  c flags: as above
  c define: PN_FBR4  AFHDS3_VERSION=1 ROLE_RX NPT_NB_CHANNELS=4 SES_NPT_NB_PORTS=4 PHY_SX1280
  c include: .;..\include;..\..;..\..\Include;..\..\AFHDS3 receiver V1
  memory RVCT4: ROM 0x8006000 size 0xf80
  memory RVCT5: ROM 0x8007000 size 0x19000
  memory RVCT9: RAM 0x20000080 size 0x8f80
  link misc: --any_placement=worst_fit
target FGr4D debug (6090000::V6.9::.\ARMCLANG)
  device: STM32G071KBUx STMicroelectronics
  pack: Keil.STM32G0xx_DFP.1.3.0
  cpu: as above
  output: FGr4D
  c flags: Optim=2 oTime=1 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: PN_FGR4D AFHDS3_VERSION=1 ROLE_RX PHY_SX1280 NPT_NB_CHANNELS=4 SES_NPT_NB_PORTS=4 DEBUG
  c include: .;..\include;..\..;..\..\Include;..\..\AFHDS3 receiver V1
  memory RVCT4: ROM 0x8006000 size 0xf80
  memory RVCT5: ROM 0x8007000 size 0x19000
  memory RVCT9: RAM 0x20000080 size 0x8f80
  link misc: --any_placement=worst_fit
target FGr4D release (6090000::V6.9::.\ARMCLANG)
  device: STM32G071KBUx STMicroelectronics
  pack: Keil.STM32G0xx_DFP.1.3.0
  cpu: as above
  output: FGr4D +hex
  AfterMake: cmd /c "Post FGr4D release.bat"
  c flags: Optim=5 oTime=1 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: PN_FGR4D AFHDS3_VERSION=1 ROLE_RX PHY_SX1280 NPT_NB_CHANNELS=4 SES_NPT_NB_PORTS=4
  c include: .;..\include;..\..;..\..\Include;..\..\AFHDS3 receiver V1
  memory RVCT4: ROM 0x8006000 size 0xf80
  memory RVCT5: ROM 0x8007000 size 0x19000
  memory RVCT9: RAM 0x20000080 size 0x8f80
  link misc: --any_placement=worst_fit
software components: CMSIS:CORE 5.1.1

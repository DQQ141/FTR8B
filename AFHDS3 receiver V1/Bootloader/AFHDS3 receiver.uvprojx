# Keil uVision project AFHDS3 receiver.uvprojx, settings and files
target FGr4B debug (6140001::V6.14.1::ARMCLANG)
  device: STM32G070CBTx STMicroelectronics
  pack: Keil.STM32G0xx_DFP.1.3.0
  cpu: IRAM(0x20000000,0x00009000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: FGr4B bootloader
  c flags: Optim=2 oTime=1 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: PN_FGR4B PHY_SX1280 BOOTLOADER DEBUG
  c include: .;..\include;..\..\Include;..\..\AFHDS3 receiver V1
  memory RVCT4: ROM 0x8000000 size 0x4800
  memory RVCT5: ROM 0x8004800 size 0x800
  memory RVCT9: RAM 0x20000080 size 0x8f80
  link misc: --any_placement=worst_fit
  group Source Group 1
    ./: startup_stm32f051x8.s startup_stm32g070xx.s startup_stm32g071xx.s Flash.c ADC.c Main.c System.c Encryption.c Resource.txt
    ../: LNK timer.c LED.c SPI SX1280.c System receiver.c Poweronch.c Encryption library M0 release.lib
    ../../Lib/: AFHDS3 CRC library M0+ release.lib Receiver bootloader SX1280 M0+ release.lib
target FGr4B RXID debug (6140001::V6.14.1::ARMCLANG)
  device: STM32G070CBTx STMicroelectronics
  pack: Keil.STM32G0xx_DFP.1.3.0
  cpu: as above
  output: FGr4B bootloader
  c flags: Optim=2 oTime=1 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: PN_FGR4B PHY_SX1280 BOOTLOADER FLASH_RXID DEBUG
  c include: .;..\include;..\..\Include;..\..\AFHDS3 receiver V1
  memory RVCT4: ROM 0x8000000 size 0x4800
  memory RVCT5: ROM 0x8004800 size 0x800
  memory RVCT9: RAM 0x20000080 size 0x8f80
  link misc: --any_placement=worst_fit
target FGr4B release (6140001::V6.14.1::ARMCLANG)
  device: STM32G070CBTx STMicroelectronics
  pack: Keil.STM32G0xx_DFP.1.3.0
  cpu: as above
  output: FGr4B bootloader +hex
  c flags: Optim=5 oTime=1 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 v6Lto=1 wLevel=2
  c define: PN_FGR4B PHY_SX1280 BOOTLOADER
  c include: .;..\include;..\..\Include;..\..\AFHDS3 receiver V1
  memory RVCT4: ROM 0x8000000 size 0x4800
  memory RVCT5: ROM 0x8004800 size 0x800
  memory RVCT9: RAM 0x20000080 size 0x8f80
  link misc: --any_placement=worst_fit
--diag_suppress L6314
target FTr8B debug (6140001::V6.14.1::ARMCLANG)
  device: STM32G070CBTx STMicroelectronics
  pack: Keil.STM32G0xx_DFP.1.3.0
  cpu: as above
  output: FTr8B bootloader
  c flags: Optim=2 oTime=1 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: PN_FTR8B PHY_SX1280 BOOTLOADER DEBUG
  c include: .;..\include;..\..\Include;..\..\AFHDS3 receiver V1
  memory RVCT4: ROM 0x8000000 size 0x4800
  memory RVCT5: ROM 0x8004800 size 0x800
  memory RVCT9: RAM 0x20000080 size 0x8f80
  link misc: --any_placement=worst_fit
target FTr8B RXID debug (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32G070CBTx STMicroelectronics
  pack: Keil.STM32G0xx_DFP.1.3.0
  cpu: as above
  output: FTr8B bootloader
  c flags: Optim=1 oTime=1 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: PN_FTR8B PHY_SX1280 BOOTLOADER FLASH_RXID DEBUG
  c include: .;..\include;..\..\Include;..\..\AFHDS3 receiver V1
  memory RVCT4: ROM 0x8000000 size 0x4800
  memory RVCT5: ROM 0x8004800 size 0x800
  memory RVCT9: RAM 0x20000080 size 0x8f80
  link misc: --any_placement=worst_fit
target FTr8B release (6140001::V6.14.1::ARMCLANG)
  device: STM32G070CBTx STMicroelectronics
  pack: Keil.STM32G0xx_DFP.1.3.0
  cpu: as above
  output: FTr8B bootloader +hex
  c flags: as above
  c define: PN_FTR8B PHY_SX1280 BOOTLOADER
  c include: .;..\include;..\..\Include;..\..\AFHDS3 receiver V1
  memory RVCT4: ROM 0x8000000 size 0x4800
  memory RVCT5: ROM 0x8004800 size 0x800
  memory RVCT9: RAM 0x20000080 size 0x8f80
  link misc: --any_placement=worst_fit
--diag_suppress L6314
target FGr8B debug (6140001::V6.14.1::ARMCLANG)
  device: STM32G070CBTx STMicroelectronics
  pack: Keil.STM32G0xx_DFP.1.3.0
  cpu: as above
  output: FGr8B bootloader
  c flags: Optim=2 oTime=1 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: PN_FGR8B PHY_SX1280 BOOTLOADER DEBUG
  c include: .;..\include;..\..\Include;..\..\AFHDS3 receiver V1
  memory RVCT4: ROM 0x8000000 size 0x4800
  memory RVCT5: ROM 0x8004800 size 0x800
  memory RVCT9: RAM 0x20000080 size 0x8f80
  link misc: --any_placement=worst_fit
target FGr8B RXID debug (6140001::V6.14.1::ARMCLANG)
  device: STM32G070CBTx STMicroelectronics
  pack: Keil.STM32G0xx_DFP.1.3.0
  cpu: as above
  output: FGr8B bootloader
  c flags: Optim=2 oTime=1 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: PN_FGR8B PHY_SX1280 BOOTLOADER FLASH_RXID DEBUG
  c include: .;..\include;..\..\Include;..\..\AFHDS3 receiver V1
  memory RVCT4: ROM 0x8000000 size 0x4800
  memory RVCT5: ROM 0x8004800 size 0x800
  memory RVCT9: RAM 0x20000080 size 0x8f80
  link misc: --any_placement=worst_fit
target FGr8B release (6140001::V6.14.1::ARMCLANG)
  device: STM32G070CBTx STMicroelectronics
  pack: Keil.STM32G0xx_DFP.1.3.0
  cpu: as above
  output: FGr8B bootloader +hex
  c flags: as above
  c define: PN_FGR8B PHY_SX1280 BOOTLOADER
  c include: .;..\include;..\..\Include;..\..\AFHDS3 receiver V1
  memory RVCT4: ROM 0x8000000 size 0x4800
  memory RVCT5: ROM 0x8004800 size 0x800
  memory RVCT9: RAM 0x20000080 size 0x8f80
  link misc: --any_placement=worst_fit
--diag_suppress L6314
target FTr12B debug (6140001::V6.14.1::ARMCLANG)
  device: STM32G070CBTx STMicroelectronics
  pack: Keil.STM32G0xx_DFP.1.3.0
  cpu: as above
  output: FTr12B bootloader
  c flags: Optim=2 oTime=1 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: PN_FTR12B PHY_SX1280 BOOTLOADER DEBUG
  c include: .;..\include;..\..\Include;..\..\AFHDS3 receiver V1
  memory RVCT4: ROM 0x8000000 size 0x4800
  memory RVCT5: ROM 0x8004800 size 0x800
  memory RVCT9: RAM 0x20000080 size 0x8f80
  link misc: --any_placement=worst_fit
target FTr12B RXID debug (6140001::V6.14.1::ARMCLANG)
  device: STM32G070CBTx STMicroelectronics
  pack: Keil.STM32G0xx_DFP.1.3.0
  cpu: as above
  output: FTr12B bootloader
  c flags: Optim=2 oTime=1 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: PN_FTR12B PHY_SX1280 BOOTLOADER FLASH_RXID DEBUG
  c include: .;..\include;..\..\Include;..\..\AFHDS3 receiver V1
  memory RVCT4: ROM 0x8000000 size 0x4800
  memory RVCT5: ROM 0x8004800 size 0x800
  memory RVCT9: RAM 0x20000080 size 0x8f80
  link misc: --any_placement=worst_fit
target FTr12B release (6140001::V6.14.1::ARMCLANG)
  device: STM32G070CBTx STMicroelectronics
  pack: Keil.STM32G0xx_DFP.1.3.0
  cpu: as above
  output: FTr12Bbootloader +hex
  c flags: as above
  c define: PN_FTR12B  PHY_SX1280 BOOTLOADER
  c include: .;..\include;..\..\Include;..\..\AFHDS3 receiver V1
  memory RVCT4: ROM 0x8000000 size 0x4800
  memory RVCT5: ROM 0x8004800 size 0x800
  memory RVCT9: RAM 0x20000080 size 0x8f80
  link misc: --any_placement=worst_fit
--diag_suppress L6314
target FGr12B debug (6140001::V6.14.1::ARMCLANG)
  device: STM32G070CBTx STMicroelectronics
  pack: Keil.STM32G0xx_DFP.1.3.0
  cpu: as above
  output: FGr12B bootloader
  c flags: Optim=2 oTime=1 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: PN_FGR12B PHY_SX1280 BOOTLOADER DEBUG
  c include: .;..\include;..\..\Include;..\..\AFHDS3 receiver V1
  memory RVCT4: ROM 0x8000000 size 0x4800
  memory RVCT5: ROM 0x8004800 size 0x800
  memory RVCT9: RAM 0x20000080 size 0x8f80
  link misc: --any_placement=worst_fit
target FGr12B RXID debug (6140001::V6.14.1::ARMCLANG)
  device: STM32G070CBTx STMicroelectronics
  pack: Keil.STM32G0xx_DFP.1.3.0
  cpu: as above
  output: FGr12B bootloader
  c flags: Optim=2 oTime=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: PN_FGR12B PHY_SX1280 BOOTLOADER FLASH_RXID DEBUG
  c include: .;..\include;..\..\Include;..\..\AFHDS3 receiver V1
  memory RVCT4: ROM 0x8000000 size 0x4800
  memory RVCT5: ROM 0x8004800 size 0x800
  memory RVCT9: RAM 0x20000080 size 0x8f80
  link misc: --any_placement=worst_fit
target FGr12B release (6140001::V6.14.1::ARMCLANG)
  device: STM32G070CBTx STMicroelectronics
  pack: Keil.STM32G0xx_DFP.1.3.0
  cpu: as above
  output: FGr12B bootloader +hex
  c flags: as above
  c define: PN_FGR12B PHY_SX1280 BOOTLOADER
  c include: .;..\include;..\..\Include;..\..\AFHDS3 receiver V1
  memory RVCT4: ROM 0x8000000 size 0x4800
  memory RVCT5: ROM 0x8004800 size 0x800
  memory RVCT9: RAM 0x20000080 size 0x8f80
  link misc: --any_placement=worst_fit
--diag_suppress L6314
target INR4-GYB debug (6090000::V6.9::.\ARMCLANG)
  device: STM32G070CBTx STMicroelectronics
  pack: Keil.STM32G0xx_DFP.1.3.0
  cpu: as above
  output: INR4-GYB bootloader
  c flags: Optim=2 oTime=1 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: PN_INR4_GYB PHY_SX1280 BOOTLOADER DEBUG
  c include: .;..\include;..\..\Include;..\..\AFHDS3 receiver V1
  memory RVCT4: ROM 0x8000000 size 0x4800
  memory RVCT5: ROM 0x8004800 size 0x800
  memory RVCT9: RAM 0x20000080 size 0x8f80
  link misc: --any_placement=worst_fit
target INR4-GYB RXID debug (6140001::V6.14.1::ARMCLANG)
  device: STM32G070CBTx STMicroelectronics
  pack: Keil.STM32G0xx_DFP.1.3.0
  cpu: as above
  output: INR4-GYB bootloader
  c flags: Optim=2 oTime=1 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: PN_INR4_GYB PHY_SX1280 BOOTLOADER FLASH_RXID DEBUG
  c include: .;..\include;..\..\Include;..\..\AFHDS3 receiver V1
  memory RVCT4: ROM 0x8000000 size 0x4800
  memory RVCT5: ROM 0x8004800 size 0x800
  memory RVCT9: RAM 0x20000080 size 0x8f80
  link misc: --any_placement=worst_fit
target INR4-GYB release (6090000::V6.9::.\ARMCLANG)
  device: STM32G070CBTx STMicroelectronics
  pack: Keil.STM32G0xx_DFP.1.3.0
  cpu: as above
  output: INR4-GYB bootloader.axf +hex
  c flags: as above
  c define: PN_INR4_GYB PHY_SX1280 BOOTLOADER
  c include: .;..\include;..\..\Include;..\..\AFHDS3 receiver V1
  memory RVCT4: ROM 0x8000000 size 0x4800
  memory RVCT5: ROM 0x8004800 size 0x800
  memory RVCT9: RAM 0x20000080 size 0x8f80
  link misc: --any_placement=worst_fit
--diag_suppress L6314
target INR6-HS debug (6140001::V6.14.1::ARMCLANG)
  device: STM32G071KBUx STMicroelectronics
  pack: Keil.STM32G0xx_DFP.1.3.0
  cpu: as above
  output: INR6-HS bootloader
  c flags: Optim=2 oTime=1 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: PN_INR6_HS PHY_SX1280 BOOTLOADER DEBUG
  c include: .;..\include;..\..\Include;..\..\AFHDS3 receiver V1
  memory RVCT4: ROM 0x8000000 size 0x4800
  memory RVCT5: ROM 0x8004800 size 0x800
  memory RVCT9: RAM 0x20000080 size 0x8f80
  link misc: --any_placement=worst_fit
target INR6-HS RXID debug (6140001::V6.14.1::ARMCLANG)
  device: STM32G071KBUx STMicroelectronics
  pack: Keil.STM32G0xx_DFP.1.3.0
  cpu: as above
  output: INR6-HS bootloader
  c flags: Optim=2 oTime=1 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: PN_INR6_HS PHY_SX1280 BOOTLOADER FLASH_RXID DEBUG
  c include: .;..\include;..\..\Include;..\..\AFHDS3 receiver V1
  memory RVCT4: ROM 0x8000000 size 0x4800
  memory RVCT5: ROM 0x8004800 size 0x800
  memory RVCT9: RAM 0x20000080 size 0x8f80
  link misc: --any_placement=worst_fit
target INR6-HS release (6140001::V6.14.1::ARMCLANG)
  device: STM32G071KBUx STMicroelectronics
  pack: Keil.STM32G0xx_DFP.1.3.0
  cpu: as above
  output: INR6-HS bootloader +hex
  c flags: as above
  c define: PN_INR6_HS PHY_SX1280 BOOTLOADER
  c include: .;..\include;..\..\Include;..\..\AFHDS3 receiver V1
  memory RVCT4: ROM 0x8000000 size 0x4800
  memory RVCT5: ROM 0x8004800 size 0x800
  memory RVCT9: RAM 0x20000080 size 0x8f80
  link misc: --any_placement=worst_fit
--diag_suppress L6314
target GMr debug (6140001::V6.14.1::ARMCLANG)
  device: STM32F051K8Ux STMicroelectronics
  pack: Keil.STM32F0xx_DFP.2.0.0
  cpu: IRAM(0x20000000,0x00002000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: GMr bootloader
  c flags: Optim=2 oTime=1 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: PN_GMR PHY_SX1280 BOOTLOADER DEBUG
  c include: .;..\include;..\..\Include;..\..\AFHDS3 receiver V1
  memory RVCT4: ROM 0x8000000 size 0x2400
  memory RVCT5: ROM 0x8002400 size 0x400
  memory RVCT9: RAM 0x20000080 size 0x1f80
  link misc: --any_placement=worst_fit
target GMr RXID debug (6140001::V6.14.1::ARMCLANG)
  device: STM32F051K8Ux STMicroelectronics
  pack: Keil.STM32F0xx_DFP.2.0.0
  cpu: as above
  output: GMr bootloader
  c flags: Optim=2 oTime=1 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: PN_GMR PHY_SX1280 BOOTLOADER FLASH_RXID DEBUG
  c include: .;..\include;..\..\Include;..\..\AFHDS3 receiver V1
  memory RVCT4: ROM 0x8000000 size 0x2400
  memory RVCT5: ROM 0x8002400 size 0x400
  memory RVCT9: RAM 0x20000080 size 0x1f80
  link misc: --any_placement=worst_fit
target GMr release (6140001::V6.14.1::ARMCLANG)
  device: STM32F051K8Ux STMicroelectronics
  pack: Keil.STM32F0xx_DFP.2.0.0
  cpu: as above
  output: GMr bootloader +hex
  c flags: as above
  c define: PN_GMR PHY_SX1280 BOOTLOADER STM32F051x8
  c include: .;..\include;..\..\Include;..\..\AFHDS3 receiver V1
  memory RVCT4: ROM 0x8000000 size 0x2400
  memory RVCT5: ROM 0x8002400 size 0x400
  memory RVCT9: RAM 0x20000080 size 0x1f80
  link misc: --any_placement=worst_fit
--diag_suppress L6314
target TMr debug (6140001::V6.14.1::ARMCLANG)
  device: STM32G071KBUx STMicroelectronics
  pack: Keil.STM32G0xx_DFP.1.3.0
  cpu: as above
  output: TMr bootloader
  c flags: Optim=2 oTime=1 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: PN_TMR PHY_SX1280 BOOTLOADER DEBUG
  c include: .;..\include;..\..\Include;..\..\AFHDS3 receiver V1
  memory RVCT4: ROM 0x8000000 size 0x4800
  memory RVCT5: ROM 0x8004800 size 0x800
  memory RVCT9: RAM 0x20000080 size 0x8f80
  link misc: --any_placement=worst_fit
target TMr RXID debug (6140001::V6.14.1::ARMCLANG)
  device: STM32G071KBUx STMicroelectronics
  pack: Keil.STM32G0xx_DFP.1.3.0
  cpu: as above
  output: TMr bootloader
  c flags: Optim=2 oTime=1 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: PN_TMR PHY_SX1280 BOOTLOADER FLASH_RXID DEBUG
  c include: .;..\include;..\..\Include;..\..\AFHDS3 receiver V1
  memory RVCT4: ROM 0x8000000 size 0x4800
  memory RVCT5: ROM 0x8004800 size 0x800
  memory RVCT9: RAM 0x20000080 size 0x8f80
  link misc: --any_placement=worst_fit
target TMr release (6140001::V6.14.1::ARMCLANG)
  device: STM32G071KBUx STMicroelectronics
  pack: Keil.STM32G0xx_DFP.1.3.0
  cpu: as above
  output: TMr bootloader +hex
  c flags: Optim=6 oTime=1 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 v6Lto=1 wLevel=2
  c define: PN_TMR PHY_SX1280 BOOTLOADER
  c include: .;..\include;..\..\Include;..\..\AFHDS3 receiver V1
  memory RVCT4: ROM 0x8000000 size 0x4800
  memory RVCT5: ROM 0x8004800 size 0x800
  memory RVCT9: RAM 0x20000080 size 0x8f80
  link misc: --any_placement=worst_fit
--diag_suppress L6314
target FBr12 debug (6140001::V6.14.1::ARMCLANG)
  device: STM32G070CBTx STMicroelectronics
  pack: Keil.STM32G0xx_DFP.1.3.0
  cpu: as above
  output: FBr12 bootloader
  c flags: Optim=2 oTime=1 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: PN_FBR12 PHY_SX1280 BOOTLOADER DEBUG
  c include: .;..\include;..\..\Include;..\..\AFHDS3 receiver V1
  memory RVCT4: ROM 0x8000000 size 0x4800
  memory RVCT5: ROM 0x8004800 size 0x800
  memory RVCT9: RAM 0x20000080 size 0x8f80
  link misc: --any_placement=worst_fit
target FBr12 RXID debug (6140001::V6.14.1::ARMCLANG)
  device: STM32G070CBTx STMicroelectronics
  pack: Keil.STM32G0xx_DFP.1.3.0
  cpu: as above
  output: FBr12 bootloader
  c flags: Optim=2 oTime=1 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: PN_FBR12 PHY_SX1280 BOOTLOADER FLASH_RXID DEBUG
  c include: .;..\include;..\..\Include;..\..\AFHDS3 receiver V1
  memory RVCT4: ROM 0x8000000 size 0x4800
  memory RVCT5: ROM 0x8004800 size 0x800
  memory RVCT9: RAM 0x20000080 size 0x8f80
  link misc: --any_placement=worst_fit
target FBr12 release (6140001::V6.14.1::ARMCLANG)
  device: STM32G070CBTx STMicroelectronics
  pack: Keil.STM32G0xx_DFP.1.3.0
  cpu: as above
  output: FBr8 bootloader +hex
  c flags: as above
  c define: PN_FBR8 PHY_SX1280 BOOTLOADER
  c include: .;..\include;..\..\Include;..\..\AFHDS3 receiver V1
  memory RVCT4: ROM 0x8000000 size 0x4800
  memory RVCT5: ROM 0x8004800 size 0x800
  memory RVCT9: RAM 0x20000080 size 0x8f80
  link misc: --any_placement=worst_fit
--diag_suppress L6314
target INR6-FC debug (6090000::V6.9::.\ARMCLANG)
  device: STM32G071KBUx STMicroelectronics
  pack: Keil.STM32G0xx_DFP.1.3.0
  cpu: as above
  output: INR6-FC bootloader
  c flags: Optim=2 oTime=1 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: PN_INR6_FC PHY_SX1280 BOOTLOADER DEBUG
  c include: .;..\include;..\..\Include;..\..\AFHDS3 receiver V1
  memory RVCT4: ROM 0x8000000 size 0x4800
  memory RVCT5: ROM 0x8004800 size 0x800
  memory RVCT9: RAM 0x20000080 size 0x8f80
  link misc: --any_placement=worst_fit
target INR6-FC-RXID debug (6140001::V6.14.1::ARMCLANG)
  device: STM32G071KBUx STMicroelectronics
  pack: Keil.STM32G0xx_DFP.1.3.0
  cpu: as above
  output: INR6-FC bootloader
  c flags: Optim=2 oTime=1 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: PN_INR6_FC PHY_SX1280 BOOTLOADER FLASH_RXID DEBUG
  c include: .;..\include;..\..\Include;..\..\AFHDS3 receiver V1
  memory RVCT4: ROM 0x8000000 size 0x4800
  memory RVCT5: ROM 0x8004800 size 0x800
  memory RVCT9: RAM 0x20000080 size 0x8f80
  link misc: --any_placement=worst_fit
target INR6-FC release (6140001::V6.14.1::ARMCLANG)
  device: STM32G071KBUx STMicroelectronics
  pack: Keil.STM32G0xx_DFP.1.3.0
  cpu: as above
  output: INR6-FC bootloader +hex
  c flags: as above
  c define: PN_INR6_FC PHY_SX1280 BOOTLOADER
  c include: .;..\include;..\..\Include;..\..\AFHDS3 receiver V1
  memory RVCT4: ROM 0x8000000 size 0x4800
  memory RVCT5: ROM 0x8004800 size 0x800
  memory RVCT9: RAM 0x20000080 size 0x8f80
  link misc: --any_placement=worst_fit
--diag_suppress L6314
target Tr8B RXID debug (6140001::V6.14.1::ARMCLANG)
  device: STM32G071KBUx STMicroelectronics
  pack: Keil.STM32G0xx_DFP.1.3.0
  cpu: as above
  output: Tr8B  bootloader
  c flags: Optim=2 oTime=1 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: PN_TR8B PHY_SX1280 BOOTLOADER FLASH_RXID DEBUG
  c include: .;..\include;..\..\Include;..\..\AFHDS3 receiver V1
  memory RVCT4: ROM 0x8000000 size 0x4800
  memory RVCT5: ROM 0x8004800 size 0x800
  memory RVCT9: RAM 0x20000080 size 0x8f80
  link misc: --any_placement=worst_fit
target Tr8B release (6140001::V6.14.1::ARMCLANG)
  device: STM32G071KBUx STMicroelectronics
  pack: Keil.STM32G0xx_DFP.1.3.0
  cpu: as above
  output: Tr8B bootloader +hex
  c flags: as above
  c define: PN_TR8B PHY_SX1280 BOOTLOADER
  c include: .;..\include;..\..\Include;..\..\AFHDS3 receiver V1
  memory RVCT4: ROM 0x8000000 size 0x4800
  memory RVCT5: ROM 0x8004800 size 0x800
  memory RVCT9: RAM 0x20000080 size 0x8f80
  link misc: --any_placement=worst_fit
--diag_suppress L6314
target FBr8 debug (6140001::V6.14.1::ARMCLANG)
  device: STM32G070CBTx STMicroelectronics
  pack: Keil.STM32G0xx_DFP.1.3.0
  cpu: as above
  output: FBr8 bootloader
  c flags: Optim=2 oTime=1 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: PN_FBR8 PHY_SX1280 BOOTLOADER DEBUG
  c include: .;..\include;..\..\Include;..\..\AFHDS3 receiver V1
  memory RVCT4: ROM 0x8000000 size 0x4800
  memory RVCT5: ROM 0x8004800 size 0x800
  memory RVCT9: RAM 0x20000080 size 0x8f80
  link misc: --any_placement=worst_fit
target FBr8 RXID debug (6140001::V6.14.1::ARMCLANG)
  device: STM32G070CBTx STMicroelectronics
  pack: Keil.STM32G0xx_DFP.1.3.0
  cpu: as above
  output: FBr8 bootloader
  c flags: Optim=2 oTime=1 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: PN_FBR8 PHY_SX1280 BOOTLOADER FLASH_RXID DEBUG
  c include: .;..\include;..\..\Include;..\..\AFHDS3 receiver V1
  memory RVCT4: ROM 0x8000000 size 0x4800
  memory RVCT5: ROM 0x8004800 size 0x800
  memory RVCT9: RAM 0x20000080 size 0x8f80
  link misc: --any_placement=worst_fit
target FBr8 release (6140001::V6.14.1::ARMCLANG)
  device: STM32G070CBTx STMicroelectronics
  pack: Keil.STM32G0xx_DFP.1.3.0
  cpu: as above
  output: FBr8 bootloader +hex
  c flags: as above
  c define: PN_FBR8 PHY_SX1280 BOOTLOADER
  c include: .;..\include;..\..\Include;..\..\AFHDS3 receiver V1
  memory RVCT4: ROM 0x8000000 size 0x4800
  memory RVCT5: ROM 0x8004800 size 0x800
  memory RVCT9: RAM 0x20000080 size 0x8f80
  link misc: --any_placement=worst_fit
--diag_suppress L6314
target FBr4 debug (6140001::V6.14.1::ARMCLANG)
  device: STM32G070CBTx STMicroelectronics
  pack: Keil.STM32G0xx_DFP.1.3.0
  cpu: as above
  output: FBr4 bootloader
  c flags: Optim=2 oTime=1 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: PN_FBR4 PHY_SX1280 BOOTLOADER DEBUG
  c include: .;..\include;..\..\Include;..\..\AFHDS3 receiver V1
  memory RVCT4: ROM 0x8000000 size 0x4800
  memory RVCT5: ROM 0x8004800 size 0x800
  memory RVCT9: RAM 0x20000080 size 0x8f80
  link misc: --any_placement=worst_fit
target FBr4 RXID debug (6140001::V6.14.1::ARMCLANG)
  device: STM32G070CBTx STMicroelectronics
  pack: Keil.STM32G0xx_DFP.1.3.0
  cpu: as above
  output: FBr4 bootloader
  c flags: Optim=2 oTime=1 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: PN_FBR4 PHY_SX1280 BOOTLOADER FLASH_RXID DEBUG
  c include: .;..\include;..\..\Include;..\..\AFHDS3 receiver V1
  memory RVCT4: ROM 0x8000000 size 0x4800
  memory RVCT5: ROM 0x8004800 size 0x800
  memory RVCT9: RAM 0x20000080 size 0x8f80
  link misc: --any_placement=worst_fit
target FBr4 release (6140001::V6.14.1::ARMCLANG)
  device: STM32G070CBTx STMicroelectronics
  pack: Keil.STM32G0xx_DFP.1.3.0
  cpu: as above
  output: FBr4 bootloader +hex
  c flags: as above
  c define: PN_FBR4 PHY_SX1280 BOOTLOADER
  c include: .;..\include;..\..\Include;..\..\AFHDS3 receiver V1
  memory RVCT4: ROM 0x8000000 size 0x4800
  memory RVCT5: ROM 0x8004800 size 0x800
  memory RVCT9: RAM 0x20000080 size 0x8f80
  link misc: --any_placement=worst_fit
--diag_suppress L6314
target FGr4D debug (6090000::V6.9::.\ARMCLANG)
  device: STM32G071KBUx STMicroelectronics
  pack: Keil.STM32G0xx_DFP.1.3.0
  cpu: as above
  output: FGr4D bootloader
  c flags: Optim=2 oTime=1 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: PN_FGR4D PHY_SX1280 BOOTLOADER DEBUG
  c include: .;..\include;..\..\Include;..\..\AFHDS3 receiver V1
  memory RVCT4: ROM 0x8000000 size 0x4800
  memory RVCT5: ROM 0x8004800 size 0x800
  memory RVCT9: RAM 0x20000080 size 0x8f80
  link misc: --any_placement=worst_fit
target FGr4D-RXID debug (6140001::V6.14.1::ARMCLANG)
  device: STM32G071KBUx STMicroelectronics
  pack: Keil.STM32G0xx_DFP.1.3.0
  cpu: as above
  output: FGr4D bootloader
  c flags: Optim=2 oTime=1 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: PN_FGR4D PHY_SX1280 BOOTLOADER FLASH_RXID DEBUG
  c include: .;..\include;..\..\Include;..\..\AFHDS3 receiver V1
  memory RVCT4: ROM 0x8000000 size 0x4800
  memory RVCT5: ROM 0x8004800 size 0x800
  memory RVCT9: RAM 0x20000080 size 0x8f80
  link misc: --any_placement=worst_fit
target FGr4D release (6090000::V6.9::.\ARMCLANG)
  device: STM32G071KBUx STMicroelectronics
  pack: Keil.STM32G0xx_DFP.1.3.0
  cpu: as above
  output: FGr4D bootloader +hex
  c flags: as above
  c define: PN_FGR4D PHY_SX1280 BOOTLOADER
  c include: .;..\include;..\..\Include;..\..\AFHDS3 receiver V1
  memory RVCT4: ROM 0x8000000 size 0x4800
  memory RVCT5: ROM 0x8004800 size 0x800
  memory RVCT9: RAM 0x20000080 size 0x8f80
  link misc: --any_placement=worst_fit
--diag_suppress L6314
software components: CMSIS:CORE 5.1.1
